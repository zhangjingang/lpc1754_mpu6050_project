# Keil uVision project lpc1754_mpu6050.uvproj, settings and files
target DebugInRAM (ARM-ADS)
  device: LPC1754 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IRAM2(0x2007C000-0x2007FFFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lpc1754_mpu6050 +hex
  c flags: Optim=4 wLevel=2
  c include: .\Board;.\CM3;.\LPC17xx;.\USER_CODE
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group CMSIS Files
    ./CM3/: core_cm3.c
    ./LPC17xx/: system_LPC17xx.c
    ./LPC17xx/Startup/: startup_LPC17xx.s
  group User Code
    ./USER_CODE/: main.c record.txt
    ./Board/: bsp_timer.c IAP.c
  group Board
    ./Board/: I2CINT.c UART0.c NRF24L01.c PT2260.c MPU6050_user.c bsp_gpioout.c bsp_key.c
    ./Board/mpu6050_dmp/: inv_mpu.c inv_mpu_dmp_motion_driver.c
target ReleasInFlash (ARM-ADS)
  device: LPC1754 NXP (founded by Philips)
  cpu: as above
  output: LPC1754_MPU6050 +hex
  c flags: Optim=4 wLevel=2
  c include: .\Board;.\CM3;.\LPC17xx\Startup;.\Board\mpu6050_dmp;.\USER_CODE
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
